# IAR project rt_thread_demo_frdmkw40z.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW40Z160xxx4 Freescale MKW40Z160xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW40Z160VHT4; TWR_K64F120M; FRDM_KW40Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../bsp/kinetis/platform/devices; ../../../../bsp/kinetis/platform/devices/MKW40Z4/include; ../../../../bsp/kinetis/platform/devices/MKW40Z4/startup; ../../../../bsp/kinetis/boards/frdmkw40z; ../../../../bsp/kinetis/common/sgtl5000; ../../../../bsp/kinetis/common/phyksz8041; ../../../../bsp/kinetis/platform/system/src/clock/MKW40Z4; ../../../../bsp/kinetis/rt_app; ../../../../bsp/kinetis/platform/drivers/inc; ../../../../bsp/kinetis/platform/hal/inc; ../../../../bsp/kinetis/rtos; ../../../../bsp/kinetis/platform/osa/inc; ../../../../bsp/kinetis/platform/CMSIS/Include; ../../../../bsp/kinetis/platform/system/inc; ../../../../bsp/kinetis/platform/utilities/inc; ../../../../bsp/kinetis/platform/utilities/src; ../../../../components/drivers/include/drivers; ../../../../components/drivers/include; ../../../../bsp/kinetis/driver_wrapper/inc; ../../../../components/finsh; ../../../../include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: appgeneric.srec
  ILINK.IlinkOutputFile: rt_thread_demo.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x2000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../bsp/kinetis/platform/devices/MKW40Z4/linker/iar/MKW40Z160xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/MKW40Z4/KsdkPlatformLib/iar/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW40Z160VHT4; TWR_K64F120M; FRDM_KW40Z; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/MKW40Z4/KsdkPlatformLib/iar/release/libksdk_platform.a
  group startup
    ../../../../bsp/kinetis/platform/devices/MKW40Z4/startup/iar/: startup_MKW40Z4.s
    ../../../../bsp/kinetis/platform/devices/MKW40Z4/startup/: system_MKW40Z4.c system_MKW40Z4.c system_MKW40Z4.c system_MKW40Z4.c system_MKW40Z4.c system_MKW40Z4.c system_MKW40Z4.c system_MKW40Z4.c system_MKW40Z4.c system_MKW40Z4.c system_MKW40Z4.c system_MKW40Z4.c
    ../../../../bsp/kinetis/platform/devices/: startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h
  group context
    ../../../../libcpu/arm/cortex-m0/: context_iar.S
  group uart_wrapper
    ../../../../bsp/kinetis/driver_wrapper/lpuart/: drv_lpuart.c fsl_lpuart_irq_rt.c
    ../../../../bsp/kinetis/driver_wrapper/inc/: drv_lpuart.h
  group board
    ../../../../bsp/kinetis/boards/frdmkw40z/: gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h
  group utils
    ../../../../bsp/kinetis/boards/frdmkw40z/: rtconfig.h
    ../../../../bsp/kinetis/platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h fsl_misc_utilities.c
    ../../../../bsp/kinetis/platform/utilities/inc/: fsl_debug_console.h
  group general
    ../../../../components/drivers/src/: completion.c pipe.c portal.c ringbuffer.c workqueue.c dataqueue.c
  group finsh
    ../../../../components/finsh/: cmd.c finsh.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_cmd.c shell.c shell.h symbol.c
  group serial
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/include/drivers/: serial.h
  group rt_core
    ../../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group app_src
    ../../../../bsp/kinetis/rt_app/: application.c startup_app.c board_app.c board_app.h
  group cortex_m0
    ../../../../libcpu/arm/cortex-m0/: cpuport.c
  group arm
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
