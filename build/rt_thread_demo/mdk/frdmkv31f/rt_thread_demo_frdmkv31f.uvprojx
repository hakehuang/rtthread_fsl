# Keil uVision project rt_thread_demo_frdmkv31f.uvprojx, settings and files
target rt_thread_demo_frdmkv31f Debug (ARM-ADS)
  device: MKV31F512xxx12 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4.fp")
  output: rt_thread_demo.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKV31F512VLL12, TWR_K64F120M
  c misc: --diag_suppress=66
  c include: ../../../../bsp/kinetis/platform/devices;../../../../bsp/kinetis/platform/devices/MKV31F51212/include;../../../../bsp/kinetis/platform/devices/MKV31F51212/startup;../../../../bsp/kinetis/boards/frdmkv31f;../../../../bsp/kinetis/common/sgtl5000;../../../../bsp/kinetis/common/phyksz8041;../../../../bsp/kinetis/platform/system/src/clock/MKV31F51212;../../../../bsp/kinetis/rt_app;../../../../bsp/kinetis/platform/drivers/inc;../../../../bsp/kinetis/platform/hal/inc;../../../../bsp/kinetis/rtos;../../../../bsp/kinetis/platform/osa/inc;../../../../bsp/kinetis/platform/CMSIS/Include;../../../../bsp/kinetis/platform/system/inc;../../../../bsp/kinetis/platform/utilities/inc;../../../../bsp/kinetis/platform/utilities/src;../../../../components/drivers/include/drivers;../../../../components/drivers/include;../../../../bsp/kinetis/driver_wrapper/inc;../../../../components/finsh;../../../../include
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ../../../../bsp/kinetis/platform/devices/MKV31F51212/linker/arm/MKV31F512xxx12_flash.scf
  link misc: ../../../../lib/ksdk_platform_lib/MKV31F51212/KsdkPlatformLib/mdk/debug/libksdk_platform.lib 
--remove 
--predefine="-D__ram_vector_table__=1"
  group startup
    ../../../../bsp/kinetis/platform/devices/MKV31F51212/startup/arm/: startup_MKV31F51212.s
    ../../../../bsp/kinetis/platform/devices/MKV31F51212/startup/: system_MKV31F51212.c system_MKV31F51212.c system_MKV31F51212.c system_MKV31F51212.c system_MKV31F51212.c system_MKV31F51212.c system_MKV31F51212.c system_MKV31F51212.c system_MKV31F51212.c system_MKV31F51212.c system_MKV31F51212.c system_MKV31F51212.c
    ../../../../bsp/kinetis/platform/devices/: startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h
  group context
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S
  group uart_wrapper
    ../../../../bsp/kinetis/driver_wrapper/uart/: drv_uart.c fsl_uart_irq_rt.c
    ../../../../bsp/kinetis/driver_wrapper/inc/: drv_uart.h
  group board
    ../../../../bsp/kinetis/boards/frdmkv31f/: gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h
  group utils
    ../../../../bsp/kinetis/boards/frdmkv31f/: rtconfig.h
    ../../../../bsp/kinetis/platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h fsl_misc_utilities.c
    ../../../../bsp/kinetis/platform/utilities/inc/: fsl_debug_console.h
  group general
    ../../../../components/drivers/src/: completion.c pipe.c portal.c ringbuffer.c workqueue.c dataqueue.c
  group finsh
    ../../../../components/finsh/: cmd.c finsh.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_cmd.c shell.c shell.h symbol.c
  group serial
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/include/drivers/: serial.h
  group rt_core
    ../../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group app_src
    ../../../../bsp/kinetis/rt_app/: application.c startup_app.c board_app.c board_app.h
  group cortex_m4
    ../../../../libcpu/arm/cortex-m4/: cpuport.c
  group arm
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
target rt_thread_demo_frdmkv31f Release (ARM-ADS)
  device: MKV31F512xxx12 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M4.fp")
  output: rt_thread_demo.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKV31F512VLL12, TWR_K64F120M
  c misc: --diag_suppress=66
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: as above
  link misc: ../../../../lib/ksdk_platform_lib/MKV31F51212/KsdkPlatformLib/mdk/release/libksdk_platform.lib 
--remove 
--predefine="-D__ram_vector_table__=1"
