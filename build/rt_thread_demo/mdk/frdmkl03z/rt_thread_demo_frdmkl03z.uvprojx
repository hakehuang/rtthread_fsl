# Keil uVision project rt_thread_demo_frdmkl03z.uvprojx, settings and files
target rt_thread_demo_frdmkl03z Debug (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0+")
  output: rt_thread_demo.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL03Z32VFK4, TWR_K64F120M
  c misc: --diag_suppress=66
  c include: ../../../../bsp/kinetis/platform/devices;../../../../bsp/kinetis/platform/devices/MKL03Z4/include;../../../../bsp/kinetis/platform/devices/MKL03Z4/startup;../../../../bsp/kinetis/boards/frdmkl03z;../../../../bsp/kinetis/common/sgtl5000;../../../../bsp/kinetis/common/phyksz8041;../../../../bsp/kinetis/platform/system/src/clock/MKL03Z4;../../../../bsp/kinetis/rt_app;../../../../bsp/kinetis/platform/drivers/inc;../../../../bsp/kinetis/platform/hal/inc;../../../../bsp/kinetis/rtos;../../../../bsp/kinetis/platform/osa/inc;../../../../bsp/kinetis/platform/CMSIS/Include;../../../../bsp/kinetis/platform/system/inc;../../../../bsp/kinetis/platform/utilities/inc;../../../../bsp/kinetis/platform/utilities/src;../../../../components/drivers/include/drivers;../../../../components/drivers/include;../../../../bsp/kinetis/driver_wrapper/inc;../../../../include
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: ../../../../bsp/kinetis/platform/devices/MKL03Z4/linker/arm/MKL03Z32xxx4_flash.scf
  link misc: ../../../../lib/ksdk_platform_lib/MKL03Z4/KsdkPlatformLib/mdk/debug/libksdk_platform.lib 
--remove 
--predefine="-D__ram_vector_table__=1"
  group startup
    ../../../../bsp/kinetis/platform/devices/MKL03Z4/startup/arm/: startup_MKL03Z4.s
    ../../../../bsp/kinetis/platform/devices/MKL03Z4/startup/: system_MKL03Z4.c system_MKL03Z4.c system_MKL03Z4.c system_MKL03Z4.c system_MKL03Z4.c system_MKL03Z4.c system_MKL03Z4.c system_MKL03Z4.c system_MKL03Z4.c system_MKL03Z4.c system_MKL03Z4.c system_MKL03Z4.c
    ../../../../bsp/kinetis/platform/devices/: startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h
  group context
    ../../../../libcpu/arm/cortex-m0/: context_rvds.S
  group uart_wrapper
    ../../../../bsp/kinetis/driver_wrapper/lpuart/: drv_lpuart.c fsl_lpuart_irq_rt.c
    ../../../../bsp/kinetis/driver_wrapper/inc/: drv_lpuart.h
  group board
    ../../../../bsp/kinetis/boards/frdmkl03z/: gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h
  group utils
    ../../../../bsp/kinetis/boards/frdmkl03z/: rtconfig.h
    ../../../../bsp/kinetis/platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h fsl_misc_utilities.c
    ../../../../bsp/kinetis/platform/utilities/inc/: fsl_debug_console.h
  group general
    ../../../../components/drivers/src/: completion.c pipe.c portal.c ringbuffer.c workqueue.c dataqueue.c
  group serial
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/include/drivers/: serial.h
  group rt_core
    ../../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group app_src
    ../../../../bsp/kinetis/rt_app/: application.c startup_app.c board_app.c board_app.h
  group cortex_m0
    ../../../../libcpu/arm/cortex-m0/: cpuport.c
  group arm
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
target rt_thread_demo_frdmkl03z Release (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0+")
  output: rt_thread_demo.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL03Z32VFK4, TWR_K64F120M
  c misc: --diag_suppress=66
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: as above
  link misc: ../../../../lib/ksdk_platform_lib/MKL03Z4/KsdkPlatformLib/mdk/release/libksdk_platform.lib 
--remove 
--predefine="-D__ram_vector_table__=1"
