# IAR project hello_world_twrk64f120m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; TWR_K64F120M; DEBUG; TOOLCHAIN_IAR; TWR_K64F120M; TARGET_K64F; CPU_MK64FN1M0VMD12; DEBUG; TOOLCHAIN_IAR
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.IExtraOptions: --cpu=Cortex-M4; --fpu=vfpv4_sp_d16; --cpu=Cortex-M4; --fpu=vfpv4_sp_d16
  ICCARM.CCIncludePath2: ../../../../bsp/kinetis/platform/devices; ../../../../bsp/kinetis/platform/devices/MK64F12/include; ../../../../bsp/kinetis/platform/devices/MK64F12/startup; ../../../../bsp/kinetis/boards/frdmk64f; ../../../../bsp/kinetis/common/sgtl5000; ../../../../bsp/kinetis/common/phyksz8041; ../../../../bsp/kinetis/platform/system/src/clock/MK64F12; ../../../../bsp/kinetis/rt_app; ../../../../bsp/kinetis/platform/drivers/inc; ../../../../bsp/kinetis/platform/hal/inc; ../../../../bsp/kinetis/rtos; ../../../../bsp/kinetis/platform/osa/inc; ../../../../bsp/kinetis/platform/CMSIS/Include; ../../../../bsp/kinetis/platform/system/inc; ../../../../bsp/kinetis/platform/utilities/inc; ../../../../bsp/kinetis/platform/utilities/src; ../../../../components/drivers/include/drivers; ../../../../components/drivers/include; ../../../../bsp/kinetis/driver_wrapper/inc; ../../../../components/finsh; ../../../../include; ../../../../pg/batches/hello_world; ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/boards/twrk64f120m; ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/devices/MK64F12; ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/devices/MK64F12/drivers; ../../../../components/finsh; ../../../../include; ../../../../bsp/kinetis/driver_wrapper/inc; ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/devices/MK64F12; ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/devices/MK64F12/drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AExtraOptionsV2: --cpu Cortex-M4; --fpu=vfpv4_sp_d16
  OBJCOPY.OOCOutputFile: appgeneric.srec
  ILINK.IlinkOutputFile: rt_thread_demo.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/devices/MK64F12/iar/MK64FN1M0xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/MK64F12/KsdkPlatformLib/iar/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; TWR_K64F120M; NDEBUG; TOOLCHAIN_IAR; TWR_K64F120M; TARGET_K64F; CPU_MK64FN1M0VMD12; TOOLCHAIN_IAR
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/MK64F12/KsdkPlatformLib/iar/release/libksdk_platform.a
  group startup
    ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/devices/MK64F12/iar/: startup_MK64F12.s
  group context
    ../../../../libcpu/arm/cortex-m4/: context_iar.S
  group hello_world
    ../../../../pg/batches/hello_world/: main.cpp
  group device
    ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/boards/twrk64f120m/: clock_config.c clock_config.h pin_mux.c pin_mux.h
    ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/devices/MK64F12/: MK64F12.h MK64F12_features.h fsl_device_registers.h system_MK64F12.h system_MK64F12.c
  group drivers
    ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/devices/MK64F12/drivers/: fsl_uart.c fsl_uart.h fsl_gpio.c fsl_gpio.h fsl_smc.c fsl_smc.h fsl_pit.c fsl_pit.h fsl_enet.c fsl_enet.h fsl_common.c fsl_common.h fsl_flash.c fsl_flash.h
  group finsh
    ../../../../components/finsh/: cmd.c finsh.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_cmd.c shell.c shell.h symbol.c
  group rt_core
    ../../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group rt_uart
    ../../../../bsp/kinetis/driver_wrapper/uart/: drv_uart.c fsl_uart_irq_rt.c
    ../../../../bsp/kinetis/driver_wrapper/inc/: drv_uart.h
  group arm
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group cortex_m4
    ../../../../libcpu/arm/cortex-m4/: cpuport.c
