# Keil uVision project hello_world_twrk64f120m.uvprojx, settings and files
target release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4.fp")
  output: motor_demo.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, TWR_K64F120M, EMPL_TARGET_KINETIS, MPU6050, EMPL, USE_DMP
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186 
--diag_suppress=66
  c include: ../../../../bsp/kinetis/platform/devices;../../../../bsp/kinetis/platform/devices/MK64F12/include;../../../../bsp/kinetis/platform/devices/MK64F12/startup;../../../../bsp/kinetis/boards/twrk64f120m;../../../../bsp/kinetis/common/sgtl5000;../../../../bsp/kinetis/common/phyksz8041;../../../../bsp/kinetis/platform/system/src/clock/MK64F12;../../../../utils/mdp/core/driver/eMPL;../../../../utils/mdp/core/driver/include;../../../../utils/mdp/core/mllite;../../../../utils/mdp/core/mpl;../../../../utils/mdp/core/eMPL-hal;../../../../bsp/kinetis/motor_app;../../../../bsp/kinetis/platform/drivers/inc;../../../../bsp/kinetis/platform/hal/inc;../../../../bsp/kinetis/rtos;../../../../bsp/kinetis/platform/osa/inc;../../../../bsp/kinetis/platform/CMSIS/Include;../../../../bsp/kinetis/platform/system/inc;../../../../bsp/kinetis/platform/utilities/inc;../../../../bsp/kinetis/platform/utilities/src;../../../../components/drivers/include/drivers;../../../../components/drivers/include;../../../../bsp/kinetis/driver_wrapper/inc;../../../../components/finsh;../../../../include
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../bsp/kinetis/platform/devices/MK64F12/linker/arm/MK64FN1M0xxx12_flash.scf
  link misc: ../../../../utils/mdp/core/mpl/arm/Keil/libmpllib_Keil_M4FP/libmpllib.lib 
../../../../lib/ksdk_platform_lib/MK64F12/KsdkPlatformLib/mdk/debug/libksdk_platform.lib 
--remove 
--predefine="-D__ram_vector_table__=1"
  group startup
    ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/devices/MK64F12/arm/: startup_MK64F12.s
  group context
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S
  group hello_world
    ../../../../pg/batches/hello_world/: main.cpp
  group device
    ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/boards/twrk64f120m/: clock_config.c clock_config.h pin_mux.c pin_mux.h
    ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/devices/MK64F12/: MK64F12.h MK64F12_features.h fsl_device_registers.h system_MK64F12.h system_MK64F12.c
  group drivers
    ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/devices/MK64F12/drivers/: fsl_uart.c fsl_uart.h fsl_gpio.c fsl_gpio.h fsl_smc.c fsl_smc.h fsl_pit.c fsl_pit.h fsl_enet.c fsl_enet.h fsl_common.c fsl_common.h fsl_flash.c fsl_flash.h
  group finsh
    ../../../../components/finsh/: cmd.c finsh.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_cmd.c shell.c shell.h symbol.c
  group rt_core
    ../../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group rt_uart
    ../../../../bsp/kinetis/driver_wrapper/uart/: drv_uart.c fsl_uart_irq_rt.c
    ../../../../bsp/kinetis/driver_wrapper/inc/: drv_uart.h
  group arm
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group cortex_m4
    ../../../../libcpu/arm/cortex-m4/: cpuport.c
target debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4.fp")
  output: motor_demo.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: as above
  group left out of the first target's files
    ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/boards/twrk64f120m/: clock_config.c clock_config.h pin_mux.c pin_mux.h
    ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/devices/MK64F12/: MK64F12.h MK64F12_features.h fsl_device_registers.h system_MK64F12.c system_MK64F12.h
    ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/devices/MK64F12/arm/: startup_MK64F12.s
    ../../../../bsp/kinetis/SDK_2.2_TWR-K64F120M/devices/MK64F12/drivers/: fsl_common.c fsl_common.h fsl_enet.c fsl_enet.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_pit.c fsl_pit.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
    ../../../../bsp/kinetis/driver_wrapper/inc/: drv_uart.h
    ../../../../bsp/kinetis/driver_wrapper/uart/: drv_uart.c fsl_uart_irq_rt.c
    ../../../../components/finsh/: cmd.c finsh.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_cmd.c shell.c shell.h symbol.c
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../../../../pg/batches/hello_world/: main.cpp
    ../../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
