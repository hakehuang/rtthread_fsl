# Keil uVision project lwip_httpssrv_wolfssl_bm.uvprojx, settings and files
target lwip_httpssrv_wolfssl_bm Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: lwip_httpssrv_wolfssl_bm.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, PRINTF_ADVANCED_ENABLE=1, FREESCALE_KSDK_BM, TWR_K64F120M, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=177,1293 
--diag_suppress=66,1296,186
  c include: ../../../../../../../platform/components/phyksz8041;../../../../../../../CMSIS/Include;../../../../../../../devices;..;../../../../../../../middleware/mmcau_2.0.0;../../../../../../../middleware/lwip_2.0.0/port;../../../../../../../middleware/lwip_2.0.0/src;../../../../../../../middleware/lwip_2.0.0/src/include;../../../../../../../middleware/lwip_2.0.0/contrib/apps;../../../../../../../middleware/wolfssl_3.9.8;../../../../../../../middleware/wolfssl_3.9.8/wolfssl/wolfcrypt/port;../../../../..;../../../../../../../devices/MK64F12/drivers;../../../../../../../devices/MK64F12/utilities;../../../../../../../devices/MK64F12
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER, DEBUG
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: ../../../../../../../middleware/mmcau_2.0.0/asm-cm4-cm7/lib_mmcau.lib 
--remove
  group startup
    ../../../../../../../devices/MK64F12/arm/: startup_MK64F12.s
    ../../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group doc
    ../: readme.txt
  group board
    ../: fsl_phy.h fsl_phy.c pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group drivers
    ../../../../../../../devices/MK64F12/drivers/: fsl_rnga.c fsl_rnga.h fsl_uart.h fsl_uart.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group lwip-src-apps-httpd
    ../../../../../../../middleware/lwip_2.0.0/src/apps/httpd/: fs.c fsdata.h httpd_structs.h
  group lwip-src-include-lwip-apps
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/apps/: fs.h httpd.h httpd_opts.h
  group lwip_httpd_wolfssl
    ../: httpd_wolfssl.c httpd_wolfssl.h
  group source
    ../: lwip_httpssrv_wolfssl_bm.c certs_buff.h
  group mmcau-mmcau_include
    ../../../../../../../middleware/mmcau_2.0.0/: cau_api.h fsl_mmcau.h
  group mmcau-mmcau_source
    ../../../../../../../middleware/mmcau_2.0.0/: fsl_mmcau.c
  group utilities
    ../../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
  group lwip-port
    ../../../../../../../middleware/lwip_2.0.0/port/: ethernetif.c ethernetif.h lwipopts.h sys_arch.c
  group lwip-port-arch
    ../../../../../../../middleware/lwip_2.0.0/port/arch/: cc.h perf.h sys_arch.h
  group lwip-src-api
    ../../../../../../../middleware/lwip_2.0.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../../../../../middleware/lwip_2.0.0/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-core-ipv4
    ../../../../../../../middleware/lwip_2.0.0/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-core-ipv6
    ../../../../../../../middleware/lwip_2.0.0/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-lwip
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group lwip-src-include-lwip-priv
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/ppp/: pppoe.h
  group lwip-src-include-posix
    ../../../../../../../middleware/lwip_2.0.0/src/include/posix/: errno.h netdb.h
  group lwip-src-include-posix-sys
    ../../../../../../../middleware/lwip_2.0.0/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../../../../../../middleware/lwip_2.0.0/src/netif/: ethernet.c lowpan6.c slipif.c
  group lwip-src-netif-ppp
    ../../../../../../../middleware/lwip_2.0.0/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip-src-include-netif-ppp
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group wolfssl-wolfssl_include
    ../../../../../../../middleware/wolfssl_3.9.8/wolfssl/: callbacks.h certs_test.h crl.h error-ssl.h internal.h ocsp.h options.h sniffer.h sniffer_error.h ssl.h test.h version.h
    ../../../../../../../middleware/wolfssl_3.9.8/wolfssl/openssl/: ec.h ssl.h bn.h
    ../../../../../../../middleware/wolfssl_3.9.8/wolfssl/wolfcrypt/: aes.h arc4.h asn.h asn_public.h blake2.h blake2-impl.h blake2-int.h camellia.h cmac.h chacha.h chacha20_poly1305.h coding.h compress.h curve25519.h des3.h dh.h dsa.h ecc.h ed25519.h error-crypt.h fe_operations.h fips_test.h ge_operations.h hash.h hc128.h hmac.h integer.h idea.h logging.h md2.h md4.h md5.h mem_track.h memory.h misc.h mpi_class.h mpi_superclass.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h ripemd.h rsa.h settings.h sha.h sha256.h sha512.h signature.h srp.h tfm.h types.h visibility.h wc_encrypt.h wc_port.h
  group wolfssl-wolfssl_source
    ../../../../../../../middleware/wolfssl_3.9.8/wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c chacha.c chacha20_poly1305.c coding.c compress.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c integer.c idea.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c signature.c srp.c tfm.c wc_encrypt.c wc_port.c
    ../../../../../../../middleware/wolfssl_3.9.8/src/: crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
  group wolfssl-wolfssl_port
    ../../../../../../../middleware/wolfssl_3.9.8/wolfcrypt/src/port/nxp/: ksdk_port.c
    ../../../../../../../middleware/wolfssl_3.9.8/wolfssl/wolfcrypt/port/nxp/: ksdk_port.h
target lwip_httpssrv_wolfssl_bm Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: lwip_httpssrv_wolfssl_bm.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VMD12, PRINTF_ADVANCED_ENABLE=1, FREESCALE_KSDK_BM, TWR_K64F120M, TOWER
  c misc: as above
  c include: as above
  asm define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: as above
