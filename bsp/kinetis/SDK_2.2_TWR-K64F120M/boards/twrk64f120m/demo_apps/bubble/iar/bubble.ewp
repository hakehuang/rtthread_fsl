# IAR project bubble.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; PRINTF_ADVANCED_ENABLE=1; TWR_K64F120M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../platform/components/mma8451q; ../../../../../CMSIS/Include; ../../../../../devices; ..; ../../..; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/utilities; ../../../../../devices/MK64F12
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: bubble.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; PRINTF_ADVANCED_ENABLE=1; TWR_K64F120M; TOWER
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../devices/MK64F12/iar/: startup_MK64F12.s
    ../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_ftm.c fsl_ftm.h fsl_i2c.h fsl_i2c.c fsl_uart.h fsl_uart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_smc.h fsl_smc.c fsl_common.h fsl_common.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group accel
    ../: fsl_mma.h fsl_mma.c
  group source
    ../: bubble.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
