# Keil uVision project dev_cdc_vnic_bm.uvprojx, settings and files
target dev_cdc_vnic_bm Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_cdc_vnic_bm.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG=1, CPU_MK64FN1M0VMD12, USB_STACK_BM, TWR_K64F120M, TOWER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..;../../../../../../middleware/usb_1.6.3;../../../../../../middleware/usb_1.6.3/osa;../../../../../../middleware/usb_1.6.3/include;../../../../../../middleware/usb_1.6.3/device;../../../../../../CMSIS/Include;../../../..;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/utilities;../../../../../../devices/MK64F12
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
  group startup
    ../../../../../../devices/MK64F12/arm/: startup_MK64F12.s
    ../../../../../../devices/MK64F12/: system_MK64F12.c system_MK64F12.h
  group usb-device-source-khci
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_khci.c usb_device_khci.h
    ../../../../../../middleware/usb_1.6.3/include/: usb_khci.h
  group board
    ../: fsl_phy.h fsl_phy.c board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group sources
    ../: virtual_nic_enet_adapter.c virtual_nic_enet_adapter.h virtual_nic_enetif.c virtual_nic_enetif.h usb_device_descriptor.c usb_device_descriptor.h virtual_nic.c virtual_nic.h usb_device_config.h
  group drivers
    ../../../../../../devices/MK64F12/drivers/: fsl_uart.h fsl_uart.c fsl_enet.h fsl_enet.c fsl_port.h fsl_sim.h fsl_sim.c fsl_clock.h fsl_clock.c fsl_sysmpu.h fsl_sysmpu.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group osa
    ../../../../../../middleware/usb_1.6.3/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group usb-device-source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb_1.6.3/device/: usb_device_dci.c usb_device_dci.h
  group usb-device-class
    ../: usb_device_class.c usb_device_class.h
  group usb-device-class-cdc
    ../: usb_device_cdc_acm.c usb_device_cdc_acm.h
  group usb-device-class-cdc_rndis
    ../: usb_device_cdc_rndis.c usb_device_cdc_rndis.h
  group utilities
    ../../../../../../devices/MK64F12/utilities/: fsl_debug_console.c fsl_debug_console.h
  group usb-include
    ../../../../../../middleware/usb_1.6.3/include/: usb.h usb_misc.h usb_spec.h
  group usb-device-include
    ../../../../../../middleware/usb_1.6.3/device/: usb_device.h
target dev_cdc_vnic_bm Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_cdc_vnic_bm.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: _DEBUG=0, CPU_MK64FN1M0VMD12, USB_STACK_BM, TWR_K64F120M, TOWER
  c misc: as above
  c include: as above
  asm define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove
