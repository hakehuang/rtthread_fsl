# Keil uVision project KsdkPlatformLib_KL03Z4.uvprojx, settings and files
target KsdkPlatformLib_KL03Z4 Debug (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0+")
  output: libksdk_platform.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL03Z32VFK4
  c misc: --diag_suppress=66
  c include: ../../../../../bsp/kinetis/platform/osa/inc;../../../../../bsp/kinetis/platform/CMSIS/Include;../../../../../bsp/kinetis/platform/devices;../../../../../bsp/kinetis/platform/devices/MKL03Z4/include;../../../../../bsp/kinetis/platform/devices/MKL03Z4/startup;../../../../../bsp/kinetis/platform/utilities/inc;../../../../../bsp/kinetis/platform/hal/inc;../../../../../bsp/kinetis/platform/drivers/inc;../../../../../bsp/kinetis/platform/system/inc;../../../../../components/drivers/include/drivers;../../../../../components/drivers/include;../../../../../bsp/kinetis/driver_wrapper/inc;../../../../../include
  asm define: DEBUG
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  group osa
    ../../../../../bsp/kinetis/platform/osa/inc/: fsl_os_abstraction.h fsl_os_abstraction_bm.h
    ../../../../../bsp/kinetis/platform/osa/src/: fsl_os_abstraction_bm.c
  group platform-clock-system
    ../../../../../bsp/kinetis/platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
    ../../../../../bsp/kinetis/platform/system/inc/: fsl_clock_manager.h
    ../../../../../bsp/kinetis/platform/system/src/clock/MKL03Z4/: fsl_clock_MKL03Z4.c fsl_clock_MKL03Z4.h
  group platform-interrupt-system
    ../../../../../bsp/kinetis/platform/system/src/interrupt/: fsl_interrupt_manager.c
    ../../../../../bsp/kinetis/platform/system/inc/: fsl_interrupt_manager.h
  group platform-hwtimer-system
    ../../../../../bsp/kinetis/platform/system/src/hwtimer/: fsl_hwtimer.c fsl_hwtimer_systick.c
    ../../../../../bsp/kinetis/platform/system/inc/: fsl_hwtimer.h fsl_hwtimer_systick.h
  group platform-power-system
    ../../../../../bsp/kinetis/platform/system/src/power/: fsl_power_manager.c fsl_power_manager_common.h
    ../../../../../bsp/kinetis/platform/system/inc/: fsl_power_manager.h
  group platform-adc16-hal
    ../../../../../bsp/kinetis/platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_adc16_hal.h
  group platform-adc16-drivers
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_adc16_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/adc16/: fsl_adc16_driver.c fsl_adc16_common.c
  group platform-cmp-hal
    ../../../../../bsp/kinetis/platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_cmp_hal.h
  group platform-cmp-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/cmp/: fsl_cmp_driver.c fsl_cmp_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_cmp_driver.h
  group platform-cop-hal
    ../../../../../bsp/kinetis/platform/hal/src/cop/: fsl_cop_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_cop_hal.h
  group platform-cop-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/cop/: fsl_cop_driver.c fsl_cop_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_cop_driver.h
  group platform-gpio-hal
    ../../../../../bsp/kinetis/platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_gpio_hal.h
  group platform-gpio-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/gpio/: fsl_gpio_common.c fsl_gpio_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_gpio_driver.h
  group platform-i2c-hal
    ../../../../../bsp/kinetis/platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_i2c_hal.h
  group platform-i2c-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/i2c/: fsl_i2c_shared_function.c fsl_i2c_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_i2c_shared_function.h
  group platform-i2c-drivers-master
    ../../../../../bsp/kinetis/platform/drivers/src/i2c/: fsl_i2c_master_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_i2c_master_driver.h
  group platform-i2c-drivers-slave
    ../../../../../bsp/kinetis/platform/drivers/src/i2c/: fsl_i2c_slave_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_i2c_slave_driver.h
  group platform-llwu-hal
    ../../../../../bsp/kinetis/platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_llwu_hal.h
  group platform-lptmr-hal
    ../../../../../bsp/kinetis/platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_lptmr_hal.h
  group platform-lptmr-drivers
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_lptmr_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/lptmr/: fsl_lptmr_driver.c fsl_lptmr_common.c
  group platform-lpuart-hal
    ../../../../../bsp/kinetis/platform/hal/src/lpuart/: fsl_lpuart_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_lpuart_hal.h
  group platform-lpuart-drivers
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_lpuart_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/lpuart/: fsl_lpuart_driver.c fsl_lpuart_common.c
  group platform-mcglite-hal
    ../../../../../bsp/kinetis/platform/hal/src/mcglite/: fsl_mcglite_hal.c fsl_mcglite_hal_modes.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_mcglite_hal.h fsl_mcglite_hal_modes.h
  group platform-osc-hal
    ../../../../../bsp/kinetis/platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_osc_hal.h
  group platform-port-hal
    ../../../../../bsp/kinetis/platform/hal/src/port/: fsl_port_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_port_hal.h
  group platform-rtc-hal
    ../../../../../bsp/kinetis/platform/hal/src/rtc/: fsl_rtc_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_rtc_hal.h
  group platform-rtc-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/rtc/: fsl_rtc_driver.c fsl_rtc_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_rtc_driver.h
  group platform-sim-hal
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_sim_hal.h
  group platform-sim-system
    ../../../../../bsp/kinetis/platform/hal/src/sim/MKL03Z4/: fsl_sim_hal_MKL03Z4.c fsl_sim_hal_MKL03Z4.h
  group platform-spi-hal
    ../../../../../bsp/kinetis/platform/hal/src/spi/: fsl_spi_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_spi_hal.h
  group platform-spi-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/spi/: fsl_spi_shared_function.c fsl_spi_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_spi_shared_function.h
  group platform-spi-drivers-master
    ../../../../../bsp/kinetis/platform/drivers/src/spi/: fsl_spi_master_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_spi_master_driver.h
  group platform-spi-drivers-slave
    ../../../../../bsp/kinetis/platform/drivers/src/spi/: fsl_spi_slave_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_spi_slave_driver.h
  group platform-smc-hal
    ../../../../../bsp/kinetis/platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_smc_hal.h
  group platform-pmc-hal
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_pmc_hal.h
  group platform-rcm-hal
    ../../../../../bsp/kinetis/platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_rcm_hal.h
  group platform-tpm-hal
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_tpm_hal.h
    ../../../../../bsp/kinetis/platform/hal/src/tpm/: fsl_tpm_hal.c
  group platform-tpm-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/tpm/: fsl_tpm_common.c fsl_tpm_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_tpm_driver.h
  group platform-vref-hal
    ../../../../../bsp/kinetis/platform/hal/src/vref/: fsl_vref_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_vref_hal.h
  group platform-vref-drivers
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_vref_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/vref/: fsl_vref_common.c fsl_vref_driver.c
target KsdkPlatformLib_KL03Z4 Release (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0+")
  output: libksdk_platform.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MKL03Z32VFK4
  c misc: --diag_suppress=66
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
