# Keil uVision project KsdkPlatformLib_KL43Z4.uvprojx, settings and files
target KsdkPlatformLib_KL43Z4 Debug (ARM-ADS)
  device: MKL43Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0plus")
  output: libksdk_platform.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL43Z256VLH4
  c misc: --diag_suppress=66
  c include: ../../../../../bsp/kinetis/platform/osa/inc;../../../../../bsp/kinetis/platform/CMSIS/Include;../../../../../bsp/kinetis/platform/devices;../../../../../bsp/kinetis/platform/devices/MKL43Z4/include;../../../../../bsp/kinetis/platform/devices/MKL43Z4/startup;../../../../../bsp/kinetis/platform/utilities/inc;../../../../../bsp/kinetis/platform/hal/inc;../../../../../bsp/kinetis/platform/drivers/inc;../../../../../bsp/kinetis/platform/system/inc;../../../../../components/drivers/include/drivers;../../../../../components/drivers/include;../../../../../bsp/kinetis/driver_wrapper/inc;../../../../../components/finsh;../../../../../include
  asm define: DEBUG
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  group osa
    ../../../../../bsp/kinetis/platform/osa/inc/: fsl_os_abstraction.h fsl_os_abstraction_bm.h
    ../../../../../bsp/kinetis/platform/osa/src/: fsl_os_abstraction_bm.c
  group platform-clock-system
    ../../../../../bsp/kinetis/platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
    ../../../../../bsp/kinetis/platform/system/inc/: fsl_clock_manager.h
    ../../../../../bsp/kinetis/platform/system/src/clock/MKL43Z4/: fsl_clock_MKL43Z4.c fsl_clock_MKL43Z4.h
  group platform-interrupt-system
    ../../../../../bsp/kinetis/platform/system/src/interrupt/: fsl_interrupt_manager.c
    ../../../../../bsp/kinetis/platform/system/inc/: fsl_interrupt_manager.h
  group platform-hwtimer-system
    ../../../../../bsp/kinetis/platform/system/src/hwtimer/: fsl_hwtimer.c fsl_hwtimer_pit.c fsl_hwtimer_systick.c
    ../../../../../bsp/kinetis/platform/system/inc/: fsl_hwtimer.h fsl_hwtimer_pit.h fsl_hwtimer_systick.h
  group platform-power-system
    ../../../../../bsp/kinetis/platform/system/src/power/: fsl_power_manager.c fsl_power_manager_common.h
    ../../../../../bsp/kinetis/platform/system/inc/: fsl_power_manager.h
  group platform-adc16-hal
    ../../../../../bsp/kinetis/platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_adc16_hal.h
  group platform-adc16-drivers
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_adc16_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/adc16/: fsl_adc16_driver.c fsl_adc16_common.c
  group platform-cmp-hal
    ../../../../../bsp/kinetis/platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_cmp_hal.h
  group platform-cmp-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/cmp/: fsl_cmp_driver.c fsl_cmp_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_cmp_driver.h
  group platform-cop-hal
    ../../../../../bsp/kinetis/platform/hal/src/cop/: fsl_cop_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_cop_hal.h
  group platform-cop-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/cop/: fsl_cop_driver.c fsl_cop_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_cop_driver.h
  group platform-dac-hal
    ../../../../../bsp/kinetis/platform/hal/src/dac/: fsl_dac_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_dac_hal.h
  group platform-dac-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/dac/: fsl_dac_driver.c fsl_dac_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_dac_driver.h
  group platform-dma-hal
    ../../../../../bsp/kinetis/platform/hal/src/dma/: fsl_dma_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_dma_hal.h
  group platform-dma-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/dma/: fsl_dma_driver.c fsl_dma_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_dma_driver.h fsl_dma_request.h
  group platform-dmamux-hal
    ../../../../../bsp/kinetis/platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_dmamux_hal.h
  group platform-flexio-hal
    ../../../../../bsp/kinetis/platform/hal/src/flexio/: fsl_flexio_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_flexio_hal.h
  group platform-flexio-hal-uart
    ../../../../../bsp/kinetis/platform/hal/src/flexio/: fsl_flexio_uart_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_flexio_uart_hal.h
  group platform-flexio-hal-spi
    ../../../../../bsp/kinetis/platform/hal/src/flexio/: fsl_flexio_spi_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_flexio_spi_hal.h
  group platform-flexio-hal-i2s
    ../../../../../bsp/kinetis/platform/hal/src/flexio/: fsl_flexio_i2s_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_flexio_i2s_hal.h
  group platform-flexio-hal-i2c
    ../../../../../bsp/kinetis/platform/hal/src/flexio/: fsl_flexio_i2c_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_flexio_i2c_hal.h
  group platform-flexio-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/flexio/: fsl_flexio_driver.c fsl_flexio_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_flexio_driver.h
  group platform-flexio-drivers-uart
    ../../../../../bsp/kinetis/platform/drivers/src/flexio/: fsl_flexio_uart_driver.c fsl_flexio_uart_dma_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_flexio_uart_driver.h fsl_flexio_uart_share.h fsl_flexio_uart_dma_driver.h
  group platform-flexio-drivers-i2s
    ../../../../../bsp/kinetis/platform/drivers/src/flexio/: fsl_flexio_i2s_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_flexio_i2s_driver.h
  group platform-flexio-drivers-spi
    ../../../../../bsp/kinetis/platform/drivers/src/flexio/: fsl_flexio_spi_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_flexio_spi_driver.h
  group platform-flexio-drivers-i2c
    ../../../../../bsp/kinetis/platform/drivers/src/flexio/: fsl_flexio_i2c_master_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_flexio_i2c_master_driver.h
  group platform-gpio-hal
    ../../../../../bsp/kinetis/platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_gpio_hal.h
  group platform-gpio-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/gpio/: fsl_gpio_common.c fsl_gpio_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_gpio_driver.h
  group platform-i2c-hal
    ../../../../../bsp/kinetis/platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_i2c_hal.h
  group platform-i2c-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/i2c/: fsl_i2c_shared_function.c fsl_i2c_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_i2c_shared_function.h
  group platform-i2c-drivers-master
    ../../../../../bsp/kinetis/platform/drivers/src/i2c/: fsl_i2c_master_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_i2c_master_driver.h
  group platform-i2c-drivers-slave
    ../../../../../bsp/kinetis/platform/drivers/src/i2c/: fsl_i2c_slave_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_i2c_slave_driver.h
  group platform-llwu-hal
    ../../../../../bsp/kinetis/platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_llwu_hal.h
  group platform-lptmr-hal
    ../../../../../bsp/kinetis/platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_lptmr_hal.h
  group platform-lptmr-drivers
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_lptmr_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/lptmr/: fsl_lptmr_driver.c fsl_lptmr_common.c
  group platform-lpuart-hal
    ../../../../../bsp/kinetis/platform/hal/src/lpuart/: fsl_lpuart_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_lpuart_hal.h
  group platform-lpuart-drivers
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_lpuart_driver.h fsl_lpuart_dma_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/lpuart/: fsl_lpuart_driver.c fsl_lpuart_common.c fsl_lpuart_dma_driver.c
  group platform-mcglite-hal
    ../../../../../bsp/kinetis/platform/hal/src/mcglite/: fsl_mcglite_hal.c fsl_mcglite_hal_modes.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_mcglite_hal.h fsl_mcglite_hal_modes.h
  group platform-osc-hal
    ../../../../../bsp/kinetis/platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_osc_hal.h
  group platform-pit-hal
    ../../../../../bsp/kinetis/platform/hal/src/pit/: fsl_pit_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_pit_hal.h
  group platform-pit-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/pit/: fsl_pit_driver.c fsl_pit_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_pit_driver.h
  group platform-port-hal
    ../../../../../bsp/kinetis/platform/hal/src/port/: fsl_port_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_port_hal.h
  group platform-rtc-hal
    ../../../../../bsp/kinetis/platform/hal/src/rtc/: fsl_rtc_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_rtc_hal.h
  group platform-rtc-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/rtc/: fsl_rtc_driver.c fsl_rtc_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_rtc_driver.h
  group platform-sai-hal
    ../../../../../bsp/kinetis/platform/hal/src/sai/: fsl_sai_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_sai_hal.h
  group platform-sai-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/sai/: fsl_sai_driver.c fsl_sai_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_sai_driver.h
  group platform-sim-hal
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_sim_hal.h
  group platform-sim-system
    ../../../../../bsp/kinetis/platform/hal/src/sim/MKL43Z4/: fsl_sim_hal_MKL43Z4.c fsl_sim_hal_MKL43Z4.h
  group platform-spi-hal
    ../../../../../bsp/kinetis/platform/hal/src/spi/: fsl_spi_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_spi_hal.h
  group platform-spi-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/spi/: fsl_spi_shared_function.c fsl_spi_common.c fsl_spi_dma_shared_function.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_spi_shared_function.h fsl_spi_dma_shared_function.h
  group platform-spi-drivers-master
    ../../../../../bsp/kinetis/platform/drivers/src/spi/: fsl_spi_master_driver.c fsl_spi_dma_master_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_spi_master_driver.h fsl_spi_dma_master_driver.h
  group platform-spi-drivers-slave
    ../../../../../bsp/kinetis/platform/drivers/src/spi/: fsl_spi_slave_driver.c fsl_spi_dma_slave_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_spi_slave_driver.h fsl_spi_dma_slave_driver.h
  group platform-smc-hal
    ../../../../../bsp/kinetis/platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_smc_hal.h
  group platform-pmc-hal
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_pmc_hal.h
  group platform-rcm-hal
    ../../../../../bsp/kinetis/platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_rcm_hal.h
  group platform-tpm-hal
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_tpm_hal.h
    ../../../../../bsp/kinetis/platform/hal/src/tpm/: fsl_tpm_hal.c
  group platform-tpm-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/tpm/: fsl_tpm_common.c fsl_tpm_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_tpm_driver.h
  group platform-uart-hal
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_uart_hal.h
    ../../../../../bsp/kinetis/platform/hal/src/uart/: fsl_uart_hal.c
  group platform-uart-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/uart/: fsl_uart_common.c fsl_uart_driver.c fsl_uart_dma_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_uart_driver.h fsl_uart_dma_driver.h
  group platform-vref-hal
    ../../../../../bsp/kinetis/platform/hal/src/vref/: fsl_vref_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_vref_hal.h
  group platform-vref-drivers
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_vref_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/vref/: fsl_vref_common.c fsl_vref_driver.c
target KsdkPlatformLib_KL43Z4 Release (ARM-ADS)
  device: MKL43Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0plus")
  output: libksdk_platform.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MKL43Z256VLH4
  c misc: --diag_suppress=66
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
