# Keil uVision project KsdkPlatformLib_K64F12.uvprojx, settings and files
target KsdkPlatformLib_K64F12 Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4.fp")
  output: libksdk_platform.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186 
--diag_suppress=66
  c include: ../../../../../bsp/kinetis/platform/osa/inc;../../../../../bsp/kinetis/platform/CMSIS/Include;../../../../../bsp/kinetis/platform/devices;../../../../../bsp/kinetis/platform/devices/MK64F12/include;../../../../../bsp/kinetis/platform/devices/MK64F12/startup;../../../../../bsp/kinetis/platform/utilities/inc;../../../../../bsp/kinetis/platform/hal/inc;../../../../../bsp/kinetis/platform/drivers/inc;../../../../../bsp/kinetis/platform/system/inc;../../../../../components/drivers/include/drivers;../../../../../components/drivers/include;../../../../../bsp/kinetis/driver_wrapper/inc;../../../../../components/finsh;../../../../../include
  asm define: DEBUG
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group osa
    ../../../../../bsp/kinetis/platform/osa/inc/: fsl_os_abstraction.h fsl_os_abstraction_bm.h
    ../../../../../bsp/kinetis/platform/osa/src/: fsl_os_abstraction_bm.c
  group platform-clock-system
    ../../../../../bsp/kinetis/platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
    ../../../../../bsp/kinetis/platform/system/inc/: fsl_clock_manager.h
    ../../../../../bsp/kinetis/platform/system/src/clock/MK64F12/: fsl_clock_MK64F12.c fsl_clock_MK64F12.h
  group platform-interrupt-system
    ../../../../../bsp/kinetis/platform/system/src/interrupt/: fsl_interrupt_manager.c
    ../../../../../bsp/kinetis/platform/system/inc/: fsl_interrupt_manager.h
  group platform-hwtimer-system
    ../../../../../bsp/kinetis/platform/system/src/hwtimer/: fsl_hwtimer.c fsl_hwtimer_pit.c fsl_hwtimer_systick.c
    ../../../../../bsp/kinetis/platform/system/inc/: fsl_hwtimer.h fsl_hwtimer_pit.h fsl_hwtimer_systick.h
  group platform-power-system
    ../../../../../bsp/kinetis/platform/system/src/power/: fsl_power_manager.c fsl_power_manager_common.h
    ../../../../../bsp/kinetis/platform/system/inc/: fsl_power_manager.h
  group platform-adc16-hal
    ../../../../../bsp/kinetis/platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_adc16_hal.h
  group platform-adc16-drivers
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_adc16_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/adc16/: fsl_adc16_driver.c fsl_adc16_common.c
  group platform-flexbus-hal
    ../../../../../bsp/kinetis/platform/hal/src/flexbus/: fsl_flexbus_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_flexbus_hal.h
  group platform-flexbus-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/flexbus/: fsl_flexbus_driver.c fsl_flexbus_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_flexbus_driver.h
  group platform-flexcan-hal
    ../../../../../bsp/kinetis/platform/hal/src/flexcan/: fsl_flexcan_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_flexcan_hal.h
  group platform-flexcan-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/flexcan/: fsl_flexcan_driver.c fsl_flexcan_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_flexcan_driver.h
  group platform-cmp-hal
    ../../../../../bsp/kinetis/platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_cmp_hal.h
  group platform-cmp-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/cmp/: fsl_cmp_driver.c fsl_cmp_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_cmp_driver.h
  group platform-cmt-hal
    ../../../../../bsp/kinetis/platform/hal/src/cmt/: fsl_cmt_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_cmt_hal.h
  group platform-cmt-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/cmt/: fsl_cmt_driver.c fsl_cmt_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_cmt_driver.h
  group platform-crc-hal
    ../../../../../bsp/kinetis/platform/hal/src/crc/: fsl_crc_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_crc_hal.h
  group platform-crc-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/crc/: fsl_crc_driver.c fsl_crc_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_crc_driver.h
  group platform-dac-hal
    ../../../../../bsp/kinetis/platform/hal/src/dac/: fsl_dac_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_dac_hal.h
  group platform-dac-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/dac/: fsl_dac_driver.c fsl_dac_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_dac_driver.h
  group platform-dmamux-hal
    ../../../../../bsp/kinetis/platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_dmamux_hal.h
  group platform-edma-hal
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_edma_hal.h
    ../../../../../bsp/kinetis/platform/hal/src/edma/: fsl_edma_hal.c
  group platform-edma-drivers
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_edma_driver.h fsl_edma_request.h
    ../../../../../bsp/kinetis/platform/drivers/src/edma/: fsl_edma_driver.c fsl_edma_common.c
  group platform-enet-hal
    ../../../../../bsp/kinetis/platform/hal/src/enet/: fsl_enet_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_enet_hal.h
  group platform-enet-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/enet/: fsl_enet_driver.c fsl_enet_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_enet_driver.h
  group platform-dspi-hal
    ../../../../../bsp/kinetis/platform/hal/src/dspi/: fsl_dspi_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_dspi_hal.h
  group platform-dspi-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/dspi/: fsl_dspi_shared_function.c fsl_dspi_common.c fsl_dspi_edma_shared_function.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_dspi_shared_function.h fsl_dspi_edma_shared_function.h
  group platform-dspi-drivers-master
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_dspi_master_driver.h fsl_dspi_edma_master_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/dspi/: fsl_dspi_master_driver.c fsl_dspi_edma_master_driver.c
  group platform-dspi-drivers-slave
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_dspi_slave_driver.h fsl_dspi_edma_slave_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/dspi/: fsl_dspi_slave_driver.c fsl_dspi_edma_slave_driver.c
  group platform-ftm-hal
    ../../../../../bsp/kinetis/platform/hal/src/ftm/: fsl_ftm_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_ftm_hal.h
  group platform-ftm-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/ftm/: fsl_ftm_driver.c fsl_ftm_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_ftm_driver.h
  group platform-gpio-hal
    ../../../../../bsp/kinetis/platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_gpio_hal.h
  group platform-gpio-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/gpio/: fsl_gpio_common.c fsl_gpio_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_gpio_driver.h
  group platform-i2c-hal
    ../../../../../bsp/kinetis/platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_i2c_hal.h
  group platform-i2c-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/i2c/: fsl_i2c_shared_function.c fsl_i2c_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_i2c_shared_function.h
  group platform-i2c-drivers-master
    ../../../../../bsp/kinetis/platform/drivers/src/i2c/: fsl_i2c_master_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_i2c_master_driver.h
  group platform-i2c-drivers-slave
    ../../../../../bsp/kinetis/platform/drivers/src/i2c/: fsl_i2c_slave_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_i2c_slave_driver.h
  group platform-llwu-hal
    ../../../../../bsp/kinetis/platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_llwu_hal.h
  group platform-lptmr-hal
    ../../../../../bsp/kinetis/platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_lptmr_hal.h
  group platform-lptmr-drivers
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_lptmr_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/lptmr/: fsl_lptmr_driver.c fsl_lptmr_common.c
  group platform-mpu-hal
    ../../../../../bsp/kinetis/platform/hal/src/mpu/: fsl_mpu_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_mpu_hal.h
  group platform-mpu-drivers
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_mpu_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/mpu/: fsl_mpu_driver.c fsl_mpu_common.c
  group platform-ewm-hal
    ../../../../../bsp/kinetis/platform/hal/src/ewm/: fsl_ewm_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_ewm_hal.h
  group platform-ewm-drivers
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_ewm_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/ewm/: fsl_ewm_driver.c fsl_ewm_common.c
  group platform-mcg-hal
    ../../../../../bsp/kinetis/platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_mcg_hal.h fsl_mcg_hal_modes.h
  group platform-osc-hal
    ../../../../../bsp/kinetis/platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_osc_hal.h
  group platform-pdb-hal
    ../../../../../bsp/kinetis/platform/hal/src/pdb/: fsl_pdb_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_pdb_hal.h
  group platform-pdb-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/pdb/: fsl_pdb_driver.c fsl_pdb_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_pdb_driver.h
  group platform-pit-hal
    ../../../../../bsp/kinetis/platform/hal/src/pit/: fsl_pit_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_pit_hal.h
  group platform-pit-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/pit/: fsl_pit_driver.c fsl_pit_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_pit_driver.h
  group platform-port-hal
    ../../../../../bsp/kinetis/platform/hal/src/port/: fsl_port_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_port_hal.h
  group platform-rtc-hal
    ../../../../../bsp/kinetis/platform/hal/src/rtc/: fsl_rtc_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_rtc_hal.h
  group platform-rtc-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/rtc/: fsl_rtc_driver.c fsl_rtc_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_rtc_driver.h
  group platform-rnga-hal
    ../../../../../bsp/kinetis/platform/hal/src/rnga/: fsl_rnga_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_rnga_hal.h
  group platform-rnga-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/rnga/: fsl_rnga_driver.c fsl_rnga_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_rnga_driver.h
  group platform-sai-hal
    ../../../../../bsp/kinetis/platform/hal/src/sai/: fsl_sai_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_sai_hal.h
  group platform-sai-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/sai/: fsl_sai_driver.c fsl_sai_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_sai_driver.h
  group platform-sdhc-hal
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_sdhc_hal.h
    ../../../../../bsp/kinetis/platform/hal/src/sdhc/: fsl_sdhc_hal.c
  group platform-sdhc-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/sdhc/: fsl_sdhc_driver.c fsl_sdhc_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_sdhc_driver.h fsl_sdhc.h
    ../../../../../bsp/kinetis/platform/composite/inc/: fsl_sdmmc_card.h
  group platform-sim-hal
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_sim_hal.h
    ../../../../../bsp/kinetis/platform/hal/src/sim/MK64F12/: fsl_sim_hal_MK64F12.c fsl_sim_hal_MK64F12.h
  group platform-smc-hal
    ../../../../../bsp/kinetis/platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_smc_hal.h
  group platform-pmc-hal
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_pmc_hal.h
  group platform-rcm-hal
    ../../../../../bsp/kinetis/platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_rcm_hal.h
  group platform-uart-hal
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_uart_hal.h
    ../../../../../bsp/kinetis/platform/hal/src/uart/: fsl_uart_hal.c
  group platform-uart-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/uart/: fsl_uart_common.c fsl_uart_driver.c fsl_uart_edma_driver.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_uart_driver.h fsl_uart_edma_driver.h
  group platform-wdog-hal
    ../../../../../bsp/kinetis/platform/hal/src/wdog/: fsl_wdog_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_wdog_hal.h
  group platform-wdog-drivers
    ../../../../../bsp/kinetis/platform/drivers/src/wdog/: fsl_wdog_driver.c fsl_wdog_common.c
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_wdog_driver.h
  group platform-vref-hal
    ../../../../../bsp/kinetis/platform/hal/src/vref/: fsl_vref_hal.c
    ../../../../../bsp/kinetis/platform/hal/inc/: fsl_vref_hal.h
  group platform-vref-drivers
    ../../../../../bsp/kinetis/platform/drivers/inc/: fsl_vref_driver.h
    ../../../../../bsp/kinetis/platform/drivers/src/vref/: fsl_vref_common.c fsl_vref_driver.c
target KsdkPlatformLib_K64F12 Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4.fp")
  output: libksdk_platform.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MK64FN1M0VMD12
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
